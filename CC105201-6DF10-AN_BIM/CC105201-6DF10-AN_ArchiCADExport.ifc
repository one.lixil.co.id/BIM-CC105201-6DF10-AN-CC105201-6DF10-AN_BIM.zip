Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2022-11-09T22:03:08
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20180216_1515(x64) - Exporter 19.0.0.405 - Alternate UI 19.0.0.405
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Nov 09 22:03:08 2022 * Host: DESKTOP-6FF1F60 * Database: C:\Users\Artec89\AppData\Local\Temp\{D3682687-02CB-46BF-BE0B-B2220C20BD0B}\ifc * Database version: 5507 * Database creation date: Wed Nov 09 22:03:07 2022 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Nov 09 22:03:08 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Nov 09 22:03:08 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm

# IfcFlowTerminal: GIX OP toilet full set,R305,ceramic lid, CC105201-6DF10-AN_REVIT:GIX OP toilet full set,R305,ceramic lid:344767
In: Level 1
Material: Ceramics
Pset_DistributionFlowElementCommon - Reference: GIX OP toilet full set,R305,ceramic lid
